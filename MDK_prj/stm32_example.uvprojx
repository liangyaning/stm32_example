# Keil uVision project stm32_example.uvprojx, settings and files
target stm32_example (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_example +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\ST_Libraries;..\Source\ST_Libraries\CMSIS;..\Source\ST_Libraries\STM32F10x_StdPeriph_Driver;..\Source\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST_Libraries
    ../Source/ST_Libraries/: stm32f10x_it.c
  group ST_Libraries\CMSIS
    ../Source/ST_Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group ST_Libraries\Startup
    ../Source/ST_Libraries/Startup/: startup_stm32f10x_md.s
  group ST_Libraries\STM32F10x_StdPeriph_Driver
    ../Source/ST_Libraries/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group User
    ../Source/User/: main.c
  group User\serial_debug
    ../Source/User/serial_debug/: serial_debug.c
  group User\Power
    ../Source/User/Power/: Power.c
